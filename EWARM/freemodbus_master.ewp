# IAR project freemodbus_master.ewp, settings and files
configuration freemodbus_master (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middleware/FreeModbus/modbus/include; ../Middleware/FreeModbus/modbus/rtu; ../Middleware/FreeModbus/modbus/; ../Middleware/FreeModbus/port/no_os; ../Middleware/FreeModbus/port; ../Bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: freemodbus_master.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Bsp
    ../Bsp/: board.h bsp.c irq_callback.c
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middleware/FreeModbus/Modbus
    ../MIddleware/FreeModbus/modbus/: mb.c mb_m.c
  group Middleware/FreeModbus/Modbus/functions
    ../MIddleware/FreeModbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
  group Middleware/FreeModbus/Modbus/rtu
    ../MIddleware/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
  group Middleware/FreeModbus/port
    ../MIddleware/FreeModbus/port/: user_mb_app.c user_mb_app_m.c
  group Middleware/FreeModbus/port/no_os
    ../MIddleware/FreeModbus/port/no_os/: port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
