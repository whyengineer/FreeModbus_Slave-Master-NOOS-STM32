<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\freemodbus_master.ewp</path>
  </project>
  <batchBuild />
</workspace>
